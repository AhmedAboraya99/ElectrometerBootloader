# IAR project ElectrometerBootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\Ahmed.AboRaya\Documents\ElectrometerBootloader\src; C:\Users\Ahmed.AboRaya\Documents\ElectrometerBootloader\linker
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ElectrometerBootloader.srec
  ILINK.IlinkOutputFile: ElectrometerBootloader.out
  ILINK.IlinkIcfFile: C:\Users\Ahmed.AboRaya\Documents\ElectrometerBootloader\linker\v85xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    stm32cube/: main.c
    D:/Electrometer/: Makefile
  group linker
    D:/Electrometer/linker/: module.icf
    linker/: stm32f401cc.icf v85xx.icf
  group scripts
    scripts/: generate_config_table.py
  group settings
    D:/Electrometer/settings/: Electrometer.crun Electrometer.dbgdt Electrometer.Debug.cspy.bat Electrometer.Debug.cspy.ps1 Electrometer.Debug.driver.xcl Electrometer.Debug.general.xcl Electrometer.dnx
  group src
    src/: core_app.c jump_table.h module1.c module2.c
